# Keil uVision project delay.uvprojx, settings and files
target STM32F103C8 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: delay +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\bus\inc;.\bus\src;.\sd\inc;.\sd\src;.\lcd\inc;.\lcd\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: main.c sandbox.c
    ./bus/src/: delay.c i2c.c timer.c USART.c
  group Headers
    ./: sandbox.h
    ./bus/inc/: delay.h i2c.h timer.h USART.h
  group SD_src
    ./sd/src/: ff.c ffunicode.c mmc_stm32f1_spi.c
  group SD_head
    ./sd/inc/: diskio.h ff.h ffconf.h stm32f100.h
  group LCD_src
    ./lcd/src/: LiquidCrystal_I2C.c lcd_i2c.c
  group LCD_head
    ./lcd/inc/: LiquidCrystal_I2C.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
